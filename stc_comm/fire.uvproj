# Keil uVision project fire.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: fire +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: fire.c uart.c flash_chip.c S29AL016D.c at24c64.c flash_chip.h stc.h type.h uart.h flash_chip_test.c AT45DB161B.c
